Commit message: go2 airy final mount

File: urdf/go2_description_airy.urdf (robot description, URDF)
Before this commit: robot go2_description, 30 links, 29 joints
Joints:
- joint rslidar_joint: origin xyz=0.03 0.0 -0.30 rpy=1.0 -1.57 0.0 -> xyz=-0.15 0.0 -0.3 rpy=0.0 -0.6681 0.0
